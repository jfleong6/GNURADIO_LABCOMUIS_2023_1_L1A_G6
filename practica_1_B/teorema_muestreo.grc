options:
  parameters:
    author: santiago_mosquera_freddy_
    generate_options: qt_gui
    id: Lab1_punto2
    output_language: python
    title: Lab1_punto2_muestreo
  states: {}

blocks:
- name: BW
  id: variable_qtgui_range
  parameters:
    label: ancho de banda
    start: '10'
    step: '10'
    stop: 50e3
    value: 1.5e3
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: f_corte
  id: variable_qtgui_range
  parameters:
    label: 'frecuencia de corte '
    start: '100'
    step: '10'
    stop: 21e3
    value: 1.5e3
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: 'frecuencia de corte '
    start: '100'
    step: '10'
    stop: 21e3
    value: 1.5e3
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: 1e3
    step: 1e3
    stop: 300e3
    value: 200e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/algomegustadeti_WY.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    nconnections: '2'
    type: float
    wintype: window.WIN_HANN
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}

connections:
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
